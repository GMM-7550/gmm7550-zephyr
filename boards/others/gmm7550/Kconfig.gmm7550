## boards/others/gmm7550/board.yml
```yaml
board:
  name: gmm7550
  full_name: GMM7550
  vendor: others
  socs:
    - name: litex_vexriscv
```
